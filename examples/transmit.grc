options:
  parameters:
    author: root
    generate_options: qt_gui
    id: transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sc16io_file_source_complex_0_1
  id: sc16io_file_source_complex
  parameters:
    filename: output.bin
    repeat: 'False'
    source_type: sc16
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    dev_addr: ''
    dev_args: addr=192.168.1.10,send_buff_size=8388608,recv_buff_size=8388608
    gain0: gain
    otw: sc8
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [sc16io_file_source_complex_0_1, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
